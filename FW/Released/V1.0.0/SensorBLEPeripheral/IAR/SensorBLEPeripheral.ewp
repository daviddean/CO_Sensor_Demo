# IAR project SensorBLEPeripheral.ewp, settings and files
configuration CC2541 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F128.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; xHAL_LCD=TRUE; HAL_LED=FALSE; xHAL_LED=TRUE; HAL_KEY=FALSE; xHAL_KEY=TRUE; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; HAL_UART=FALSE; xHAL_UART=TRUE; xFAKE_SENS_DATA; xO2_SENSOR; CO_SENSOR
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Batt; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Keys; ..\..\Profiles\Proximity; ..\..\Profiles\Roles; ..\..\Profiles\ScanParam; ..\..\Profiles\Sensor; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Thermometer; ..\Source
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DK-MINI Keyfob (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  group APP
    ../Source/: OSAL_SensorBLEPeripheral.c sensorBLEPeripheral.c sensorBLEPeripheral.h sensorBLEPeripheral_Main.c TI_CC2541_LMP91000_i2c.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../Source/: hal_adc.c hal_i2c.c
    ../../../../Components/hal/target/CC2540EB/: hal_aes.c hal_dma.c hal_flash.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/hci/: hci_c_data.h hci_c_event.h hci_controller.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h ll_sleep.h phy.h phy_image.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_ble_single_chip_peri_observ.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/: battservice.c
    ../Source/: broadcaster.c
    ../../Profiles/DevInfo/: devinfoservice.c
    ../../Profiles/Roles/: gap.c gapbondmgr.c peripheral.c
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/Sensor/: sensorservice.c
  group TOOLS
    ./: buildConfig.cfg
    ../Source/: OnBoard.c
